** Compensated OPAmp **
*
* NI Multisim to SPICE Netlist Export
* Generated by: majed
* Sun, Jun 14, 2020 16:49:50
*

*## Multisim Component C1 ##*
* !!!BEGIN-INTERACT
*  : delay_factor ++++i2   ;
*  : setval       ++++f4   ;
*  : ratedval     ++++f6   ;
*  : init_cond    ++++f8   ;
*  0          constant  S_OK
*  1e-15      VARIABLE  capblown
*  0.0        VARIABLE  flag
*  0.0        VARIABLE  r1Cur
*  0.0        VARIABLE  c1Voltage
*  0.0        VARIABLE  resistance
*  0          VARIABLE  cnt
*  1          VARIABLE  delaytime
*  0          VARIABLE  S_BLOWN
*
* : DELAY
*  *delaytime  0 do
*          *cnt 1+ ==>_*cnt
*          *cnt *delaytime =  if
*          *S_BLOWN 1 + ==>_*S_BLOWN
*          0 ==>_*cnt
*          endif
*   loop
*   *S_BLOWN ==>_*animation_state
* ;
*
* : RESET
*       delay_factor 10000 * ==>_*delaytime
*       0.0 ==>_*flag
*       0.0 ==>_*c1Voltage
*       0.0 ==>_*r1Cur
*       1e15 ==>_*resistance
*       S_OK   ==>_*animation_state
*       0 ==>_*S_BLOWN
* ;
*
*  :BEGIN_PLOT
*         RESET
*  ;
*
*  : C_BLOWN
*      *capblown  resistance   GRADUAL_CHANGE_AT_RUN
*  ;
*
*  :GRADUAL_CHANGE_AT_RUN locals| ref value |
*     value     SET_INSTANCE Resistor ::R r1 resistance
*  ;
*
*  :OUT_DATA
*   1.0 *flag f.> if
*     GET_INSTANCE Resistor ::R r1  i  ==>_*r1Cur
*     *r1Cur f.abs 1e30 f.* ==>_*c1Voltage
*     ratedval *c1Voltage f.< if
*          1.0 ==>_*flag
*          DELAY
*          DELAY
*          DELAY
*          DELAY
*          DELAY
*          C_BLOWN
*     endif
*   endif
*  ;
*
* :BEGIN_ANALYSIS
*     RESET
* ;
*
* !!!END-INTERACT
xC1 10 7 virtual_capC1
.subckt virtual_capC1 1 2
r1 1 2 1e30
c1 1 2 1e-008  IC=0
.ends

*## Multisim Component R6 ##*
rR6 4 10 100 vresR6
.model vresR6 r(  )

*## Multisim Component R4 ##*
rR4 6 VEE 18000 vresR4
.model vresR4 r(  )

*## Multisim Component R5 ##*
rR5 Vout VEE 16000 vresR5
.model vresR5 r(  )

*## Multisim Component R3 ##*
rR3 9 VEE 8.2 vresR3
.model vresR3 r(  )

*## Multisim Component Q5 ##*
qQ5 6 4 8 2N3906__BJT_PNP__1

*## Multisim Component VEE ##*
VEEVEE  VEE 0 dc -15

*## Multisim Component R16 ##*
rR16 VCC 1 10000 vresR16
.model vresR16 r(  )

*## Multisim Component R2 ##*
rR2 9 5 18 vresR2
.model vresR2 r(  )

*## Multisim Component R1 ##*
rR1 3 9 18 vresR1
.model vresR1 r(  )

*## Multisim Component R18 ##*
rR18 VCC 8 10000 vresR18
.model vresR18 r(  )

*## Multisim Component Q3 ##*
qQ3 VCC 6 Vout NPN__TRANSISTORS_VIRTUAL__1

*## Multisim Component VCC ##*
VCCVCC  VCC 0 dc 15

*## Multisim Component Q2 ##*
qQ2 4 7 5 NPN__TRANSISTORS_VIRTUAL__1

*## Multisim Component Q1 ##*
qQ1 1 2 3 NPN__TRANSISTORS_VIRTUAL__1

*## Multisim Component R17 ##*
rR17 VCC 4 10000 vresR17
.model vresR17 r(  )

.MODEL NPN__TRANSISTORS_VIRTUAL__1 NPN

.MODEL 2N3906__BJT_PNP__1   PNP(Is=1.41f Xti=3 Eg=1.11 Vaf=18.7 Bf=180.7 Ne=1.5 Ise=0
+               Ikf=80m Xtb=1.5 Br=4.977 Nc=2 Isc=0 Ikr=0 Rc=2.5 Cjc=9.728p
+               Mjc=.5776 Vjc=.75 Fc=.5 Cje=8.063p Mje=.3677 Vje=.75 Tr=33.42n
+               Tf=179.3p Itf=.4 Vtf=4 Xtf=6 Rb=10)
